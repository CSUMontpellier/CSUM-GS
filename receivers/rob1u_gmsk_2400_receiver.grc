options:
  parameters:
    author: CSUM
    category: Custom
    description: GR Flowgraph to decode ROBUSTA 1U frames
    generate_options: qt_gui
    id: rob1u_gmsk_2400_receiver
    output_language: python
    run_options: run
    title: rob1u_gmsk_2400_receiver
  states: {}

blocks:
- name: cc_gain
  id: variable
  parameters:
    value: 0.25*0.175*0.175
  states: {}
- name: cc_mu
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: cc_mu_gain
  id: variable
  parameters:
    value: '0.175'
  states: {}
- name: cc_omega_lim
  id: variable
  parameters:
    value: '0.002'
  states: {}
- name: dec_factor
  id: variable
  parameters:
    value: '20'
  states: {}
- name: demod_gain
  id: variable
  parameters:
    value: (samp_rate_dec)/(2*math.pi*default_dev)
  states: {}
- name: freq_doppler
  id: variable
  parameters:
    value: '0'
  states: {}
- name: low_pass_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '50000'
    gain: '1.0'
    samp_rate: samp_rate
    width: '5000'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_taps_2
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: default_baud
    gain: '1.0'
    samp_rate: samp_rate_dec
    width: 0.75*default_baud
    win: firdes.WIN_HAMMING
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: RX Power Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '72'
    value: '72'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1920000'
  states: {}
- name: samp_rate_dec
  id: variable
  parameters:
    value: samp_rate/dec_factor
  states: {}
- name: sps_dec_factor
  id: variable
  parameters:
    value: int(samp_rate_dec/(sps_rx*default_baud))
  states: {}
- name: sps_rx
  id: variable
  parameters:
    value: '10'
  states: {}
- name: t_points
  id: variable
  parameters:
    value: '5000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '-(default_freq-freq_doppler)'
    type: float
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: demod_gain
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: default_baud
  id: parameter
  parameters:
    short_id: b
    type: intx
    value: '2400'
  states: {}
- name: default_dev
  id: parameter
  parameters:
    label: Input
    short_id: j
    type: eng_float
    value: '600'
  states: {}
- name: default_freq
  id: parameter
  parameters:
    short_id: f
    type: intx
    value: '436500000'
  states: {}
- name: default_sdr_address
  id: parameter
  parameters:
    short_id: i
    value: '"ip:pluto-mission-test.local"'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: cc_mu_gain
    gain_omega: 0.25*0.175*0.175
    mu: cc_mu
    omega: sps_rx
    omega_relative_limit: cc_omega_lim
    type: float
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: sps_dec_factor
    taps: low_pass_taps_2
    type: fff
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: default_freq-freq_doppler
    decim: int(dec_factor)
    samp_rate: samp_rate
    taps: low_pass_taps
    type: ccc
  states: {}
- name: gpredict_doppler_0
  id: gpredict_doppler
  parameters:
    gpredict_host: localhost
    gpredict_port: '4532'
    target: freq_doppler
  states: {}
- name: iio_fmcomms2_source_0
  id: iio_fmcomms2_source
  parameters:
    auto_filter: 'True'
    bandwidth: '2000000'
    bbdc: 'True'
    buffer_size: '0x8000'
    frequency: default_freq
    gain1: '''manual'''
    manual_gain1: rx_gain
    quadrature: 'True'
    rf_port_select: '''A_BALANCED'''
    rfdc: 'True'
    rx1_en: 'True'
    rx2_en: 'False'
    samplerate: samp_rate
    uri: default_sdr_address
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 0,1,1,1
    label1: Dopper Correction
    max: '10000'
    min: '-10000'
    type: float
    unit1: Hz
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 1,0,4,1
    label1: ''
    name: ''
    size: t_points*2
    srate: samp_rate_dec
    type: float
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate_dec
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,0,4,2
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: satellites_hdlc_deframer_0
  id: satellites_hdlc_deframer
  parameters:
    check_fcs: 'True'
    max_length: '300'
  states: {}
- name: satellites_nrzi_decode_0
  id: satellites_nrzi_decode
  parameters: {}
  states: {}
- name: satellites_submit_0
  id: satellites_submit
  parameters:
    latitude: '0'
    longitude: '0'
    noradID: '152225'
    source: AAAAAA
    url: http://localhost:7000/store_beacon
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: receiver_out
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: bitstream_out
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: receiver_out
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: bitstream_out
  states: {}

connections:
- [analog_const_source_x_0, '0', qtgui_number_sink_0, '0']
- [analog_quadrature_demod_cf_0, '0', fir_filter_xxx_0_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0_0_0_0_0, '0']
- [digital_binary_slicer_fb_0, '0', satellites_nrzi_decode_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', virtual_sink_0_0, '0']
- [fir_filter_xxx_0_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', virtual_sink_0, '0']
- [iio_fmcomms2_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [satellites_hdlc_deframer_0, out, blocks_message_debug_0, print_pdu]
- [satellites_hdlc_deframer_0, out, satellites_submit_0, in]
- [satellites_nrzi_decode_0, '0', satellites_hdlc_deframer_0, '0']
- [virtual_source_0, '0', analog_quadrature_demod_cf_0, '0']
- [virtual_source_0_0, '0', digital_binary_slicer_fb_0, '0']

metadata:
  file_format: 1
