options:
  parameters:
    author: CSUM
    copyright: CSUM
    description: Demodulates signals from CSUM satellites in GMSK 9600 bps and deframe their AX.25 packets.
    generate_options: no_gui
    id: csum_demod_gmsk9k6
    output_language: python
    run_options: run
    title: GMSK9k6 demodulator and AX.25 deframer for CSUM satellites.
  states: {}

blocks:
- name: baudrate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: demod_samp_rate
  id: variable
  parameters:
    value: '19200'
  states: {}
- name: in_samp_rate
  id: variable
  parameters:
    value: '153600'
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: demod_samp_rate/(2*math.pi*baudrate/4)
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: |-
      - Output CF32 IQs at a rate of 153600 Hz.
      - If your IQs file have a different sampling rate, 
      use a "Rational Resampler" right after this block
      to convert the sampling rate.
    file: iqs_file_path
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: throttle_test
    type: complex
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '0.0001'
    loop_bw: '0.045'
    max_dev: '0.00268'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: demod_samp_rate//baudrate
    ted_gain: '0.038'
    ted_type: digital.TED_ZERO_CROSSING
    type: ff
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    pkt_cntr = 0\n\n    def __init__(self):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Embedded Python Block',   # will show up in GRC\n            in_sig=None,\n            out_sig=None\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.message_port_register_in(pmt.intern(\"msgin\"))\n        self.set_msg_handler(pmt.intern('msgin'), self.msg_handler)\n\n    def msg_handler(self, msg):\n        self.pkt_cntr += 1\n        print(\"--------------------------\")\n        print(bytearray(pmt.to_python(pmt.cdr(msg))).hex(\" \"))\n        # print(\"Received \"+str(self.pkt_cntr)+\" packets.\")\n\n    def stop(self):\n        print(\"Received \"+str(self.pkt_cntr)+\" packets.\")\n\n\n"
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: iqs_file_path
  id: parameter
  parameters:
    label: '"Path to the IQs file."'
    short_id: f
    type: str
    value: '""'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: in_samp_rate//demod_samp_rate
    gain: '1'
    ntaps: in_samp_rate//baudrate*8
    samp_rate: in_samp_rate
    sym_rate: baudrate*1
    type: fir_filter_ccf
  states: {}
- name: satellites_ax25_deframer_0
  id: satellites_ax25_deframer
  parameters:
    g3ruh_scrambler: 'False'
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: print("\033[38;5;70mDemodulator GMSK9k6 started.\033[0m")
    section: main_after_start
  states: {}
- name: throttle_test
  id: parameter
  parameters:
    label: '"Set this value to in_samp_rate to run it in real-time. The higher the throttle, the quicker the file is processed."'
    short_id: t
    type: intx
    value: '153600'
  states: {}

connections:
- [analog_quadrature_demod_cf_0_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', root_raised_cosine_filter_0, '0']
- [digital_symbol_sync_xx_0, '0', satellites_ax25_deframer_0, '0']
- [root_raised_cosine_filter_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [satellites_ax25_deframer_0, out, epy_block_0, msgin]

metadata:
  file_format: 1
  grc_version: 3.10.7.0
