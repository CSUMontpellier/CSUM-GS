options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: csp_afsk_1200_receiver
    output_language: python
    run_options: run
    title: csp_afsk_1200_receiver
  states: {}

blocks:
- name: cc_gain
  id: variable
  parameters:
    value: 0.25*0.175*0.175
  states: {}
- name: cc_mu
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: cc_mu_gain
  id: variable
  parameters:
    value: '0.175'
  states: {}
- name: cc_omega_lim
  id: variable
  parameters:
    value: '0.002'
  states: {}
- name: cc_omega_lim_0
  id: variable
  parameters:
    value: '0.002'
  states: {}
- name: dec_factor
  id: variable
  parameters:
    value: '20'
  states: {}
- name: default_ip
  id: variable
  parameters:
    value: '"tcp://127.0.0.1" '
  states: {}
- name: demod_gain
  id: variable
  parameters:
    value: '30.5577'
  states: {}
- name: low_pass_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: samp_rate_dec/2
    gain: '1.0'
    samp_rate: samp_rate
    width: '5000'
    win: firdes.WIN_HAMMING
  states: {}
- name: max_track_freq
  id: variable
  parameters:
    value: 2 * math.pi * 10000 / samp_rate_dec
  states: {}
- name: nbfm_low_pass_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: default_freq_mark-default_freq_central
    gain: '1.0'
    samp_rate: samp_rate_dec
    width: '400'
    win: firdes.WIN_HAMMING
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: RX Power Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '72'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1920000'
  states: {}
- name: samp_rate_dec
  id: variable
  parameters:
    value: '96000'
  states: {}
- name: sps_dec_factor
  id: variable
  parameters:
    value: '10'
  states: {}
- name: sps_rx
  id: variable
  parameters:
    value: samp_rate_dec/default_baud
  states: {}
- name: t_points
  id: variable
  parameters:
    value: '5000'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: samp_rate_dec
    max_dev: 5e3
    quad_rate: samp_rate_dec
    tau: '75e-6'
  states: {}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters:
    max_freq: max_track_freq
    min_freq: '-max_track_freq'
    w: math.pi/200
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: demod_gain
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    ok_to_block: 'False'
    samp_rate: samp_rate_dec
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: default_baud
  id: parameter
  parameters:
    short_id: b
    type: intx
    value: '1200'
  states: {}
- name: default_dev
  id: parameter
  parameters:
    label: Input
    short_id: j
    type: eng_float
    value: '500'
  states: {}
- name: default_freq
  id: parameter
  parameters:
    short_id: f
    type: intx
    value: '437000000'
  states: {}
- name: default_freq_central
  id: parameter
  parameters:
    label: Input
    short_id: c
    type: eng_float
    value: '1700'
  states: {}
- name: default_freq_mark
  id: parameter
  parameters:
    label: Input
    short_id: m
    type: eng_float
    value: '2200'
  states: {}
- name: default_freq_space
  id: parameter
  parameters:
    label: Input
    short_id: o
    type: eng_float
    value: '1200'
  states: {}
- name: default_sdr_address
  id: parameter
  parameters:
    short_id: i
    value: '"ip:pluto-mission-test.local"'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: cc_mu_gain
    gain_omega: 0.25*0.175*0.175
    mu: cc_mu
    omega: sps_rx/sps_dec_factor
    omega_relative_limit: cc_omega_lim
    type: float
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: int(dec_factor)
    samp_rate: samp_rate
    taps: low_pass_taps
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: default_freq_central
    decim: '1'
    samp_rate: samp_rate_dec
    taps: nbfm_low_pass_taps
    type: fcc
  states: {}
- name: iio_fmcomms2_source_0
  id: iio_fmcomms2_source
  parameters:
    auto_filter: 'True'
    bandwidth: '2000000'
    bbdc: 'True'
    buffer_size: '0x8000'
    frequency: default_freq
    gain1: '''manual'''
    manual_gain1: rx_gain
    quadrature: 'True'
    rf_port_select: '''A_BALANCED'''
    rfdc: 'True'
    rx1_en: 'True'
    rx2_en: 'False'
    samplerate: samp_rate
    uri: default_sdr_address
  states: {}
- name: pub_port
  id: parameter
  parameters:
    short_id: p
    type: intx
    value: '5600'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate_dec/sps_dec_factor
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate_dec
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,0,2,1
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: sps_dec_factor
    interp: '1'
    taps: ''
    type: fff
  states: {}
- name: satellites_nrzi_decode_0
  id: satellites_nrzi_decode
  parameters: {}
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: nbfm_out
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: nbfm_out
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: default_ip + ":" + str(pub_port)
    timeout: '100'
    type: byte
  states: {}

connections:
- [analog_nbfm_rx_0, '0', audio_sink_0, '0']
- [analog_nbfm_rx_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [analog_pll_carriertracking_cc_0, '0', analog_nbfm_rx_0, '0']
- [analog_quadrature_demod_cf_0, '0', rational_resampler_xxx_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', zeromq_pub_sink_0, '0']
- [digital_binary_slicer_fb_0, '0', satellites_nrzi_decode_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', qtgui_time_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_pll_carriertracking_cc_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', virtual_sink_0, '0']
- [iio_fmcomms2_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [rational_resampler_xxx_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [satellites_nrzi_decode_0, '0', blocks_pack_k_bits_bb_0_0, '0']
- [virtual_source_0, '0', analog_quadrature_demod_cf_0, '0']

metadata:
  file_format: 1
