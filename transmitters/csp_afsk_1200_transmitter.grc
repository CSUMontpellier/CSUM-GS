options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: csp_afsk_1200_transmitter
    output_language: python
    run_options: run
    title: csp_afsk_1200_transmitter
  states: {}

blocks:
- name: attenuation
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Signal Attenuation
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '20'
  states: {}
- name: audio_samp
  id: variable
  parameters:
    value: '96000'
  states: {}
- name: default_bandwidth
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: default_ip
  id: variable
  parameters:
    value: '"tcp://127.0.0.1" '
  states: {}
- name: default_tx_freq
  id: variable
  parameters:
    value: '437000000'
  states: {}
- name: interp_tx
  id: variable
  parameters:
    value: audio_samp/default_baud
  states: {}
- name: low_pass_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 2*(3000+default_freq_mark)
    gain: '0.8'
    samp_rate: audio_samp
    width: '1000'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_taps_0
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '20000'
    gain: '1'
    samp_rate: sdr_samp
    width: '4000'
    win: firdes.WIN_HAMMING
  states: {}
- name: rf_tune
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Frequency Deviation
    orient: Qt.Horizontal
    rangeType: int
    start: '-2000'
    step: '10'
    stop: '2000'
    value: '0'
  states: {}
- name: sdr_samp
  id: variable
  parameters:
    value: default_baud*1600
  states: {}
- name: sensitivity
  id: variable
  parameters:
    value: 2*math.pi*default_dev/audio_samp
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: audio_samp
    fh: '-1.0'
    max_dev: 3e3
    quad_rate: audio_samp
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_samp
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_LSB_FIRST
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: default_baud
  id: parameter
  parameters:
    short_id: b
    type: intx
    value: '1200'
  states: {}
- name: default_dev
  id: parameter
  parameters:
    label: Input
    short_id: j
    type: eng_float
    value: '500'
  states: {}
- name: default_freq_central
  id: parameter
  parameters:
    label: Input
    short_id: c
    type: eng_float
    value: '1700'
  states: {}
- name: default_freq_mark
  id: parameter
  parameters:
    label: Input
    short_id: m
    type: eng_float
    value: '2200'
  states: {}
- name: default_freq_space
  id: parameter
  parameters:
    label: Input
    short_id: o
    type: eng_float
    value: '1200'
  states: {}
- name: default_sdr_address
  id: parameter
  parameters:
    short_id: i
    value: '"ip:pluto-mission-test.local"'
  states: {}
- name: digital_gfsk_mod_0_0
  id: digital_gfsk_mod
  parameters:
    bt: '1'
    samples_per_symbol: int(interp_tx)
    sensitivity: sensitivity
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: rf_tune
    decim: '1'
    samp_rate: sdr_samp
    taps: low_pass_taps
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: default_freq_central
    decim: '1'
    samp_rate: audio_samp
    taps: low_pass_taps
    type: ccc
  states: {}
- name: iio_fmcomms2_sink_0
  id: iio_fmcomms2_sink
  parameters:
    attenuation1: attenuation
    auto_filter: 'True'
    bandwidth: default_bandwidth
    buffer_size: '0x8000'
    cyclic: 'False'
    frequency: default_tx_freq
    rf_port_select: '''A'''
    samplerate: sdr_samp
    tx1_en: 'True'
    tx2_en: 'False'
    uri: default_sdr_address
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: note_0
  id: note
  parameters:
    note: S=2pi fdev / frate_out
  states: {}
- name: note_1
  id: note
  parameters:
    note: Diff encoder ref = 0
  states: {}
- name: qtgui_waterfall_sink_x_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: sdr_samp
    fc: '0'
    fftsize: '1024'
    gui_hint: 2,0,5,1
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: int(sdr_samp/audio_samp)
    taps: ''
    type: ccc
  states: {}
- name: satellites_nrzi_encode_0
  id: satellites_nrzi_encode
  parameters: {}
  states: {}
- name: sub_port
  id: parameter
  parameters:
    short_id: s
    type: intx
    value: '5500'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: modulator_out
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: nbfm_out
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: modulator_out
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: nbfm_out
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: default_ip + ":" + str(sub_port)
    timeout: '100'
    type: byte
  states: {}

connections:
- [analog_nbfm_tx_0, '0', virtual_sink_1, '0']
- [blocks_complex_to_real_0, '0', analog_nbfm_tx_0, '0']
- [blocks_complex_to_real_0, '0', audio_sink_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', satellites_nrzi_encode_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', digital_gfsk_mod_0_0, '0']
- [digital_gfsk_mod_0_0, '0', virtual_sink_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', iio_fmcomms2_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', blocks_complex_to_real_0, '0']
- [rational_resampler_xxx_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_waterfall_sink_x_0_1, '0']
- [satellites_nrzi_encode_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [virtual_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [virtual_source_1, '0', rational_resampler_xxx_0, '0']
- [zeromq_sub_source_0, '0', blocks_packed_to_unpacked_xx_0, '0']

metadata:
  file_format: 1
