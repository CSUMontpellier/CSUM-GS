options:
  parameters:
    author: CSUM
    category: Custom
    description: GR Flowgraph to encode ROB1D frames
    generate_options: qt_gui
    id: ax25_gmsk_2400_transmitter
    output_language: python
    run_options: run
    title: ax25_gmsk_2400_transmitter
  states: {}

blocks:
- name: attenuation
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Signal Attenuation
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '20'
  states: {}
- name: default_bandwidth
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: default_ip
  id: variable
  parameters:
    value: '"tcp://127.0.0.1" '
  states: {}
- name: default_tx_freq
  id: variable
  parameters:
    value: '435500000'
  states: {}
- name: interp_tx
  id: variable
  parameters:
    value: sdr_samp/default_baud
  states: {}
- name: low_pass_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '500000'
    gain: '1'
    samp_rate: sdr_samp
    width: '50000'
    win: firdes.WIN_HAMMING
  states: {}
- name: rf_tune
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Frequency Deviation
    orient: Qt.Horizontal
    rangeType: int
    start: '-2000'
    step: '10'
    stop: '2000'
    value: '0'
  states: {}
- name: sdr_samp
  id: variable
  parameters:
    value: default_baud*800
  states: {}
- name: sensitivity
  id: variable
  parameters:
    value: 2*math.pi*default_dev/sdr_samp
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.PMT_NIL, pmt.pmt_to_python.numpy_to_uvector(numpy.array([ord(c) for c in "aaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaa"], numpy.uint8)))
    period: '1000'
  states: {state: disabled}
- name: blocks_pdu_set_0
  id: blocks_pdu_set
  parameters:
    k: pmt.intern("key")
    v: pmt.intern("value")
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '255'
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: default_baud
  id: parameter
  parameters:
    short_id: b
    type: intx
    value: '2400'
  states: {}
- name: default_dev
  id: parameter
  parameters:
    label: Input
    short_id: j
    type: eng_float
    value: '600'
  states: {}
- name: default_sdr_address
  id: parameter
  parameters:
    short_id: i
    value: '"ip:pluto-mission-test.local"'
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.5'
    samples_per_symbol: int(interp_tx)
    sensitivity: sensitivity
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: rf_tune
    decim: '1'
    samp_rate: sdr_samp
    taps: low_pass_taps
  states: {}
- name: iio_fmcomms2_sink_0
  id: iio_fmcomms2_sink
  parameters:
    attenuation1: attenuation
    auto_filter: 'True'
    bandwidth: default_bandwidth
    buffer_size: '0x8000'
    cyclic: 'False'
    frequency: default_tx_freq
    rf_port_select: '''A'''
    samplerate: sdr_samp
    tx1_en: 'True'
    tx2_en: 'False'
    uri: default_sdr_address
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: note_0
  id: note
  parameters:
    note: S=2pi fdev / frate_out
  states: {}
- name: note_1
  id: note
  parameters:
    note: Diff encoder ref = 0
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: sdr_samp
    fc: '0'
    fftsize: '1024'
    gui_hint: 2,0,5,1
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: satellites_hdlc_framer_0
  id: satellites_hdlc_framer
  parameters:
    postamble_bytes: '7'
    preamble_bytes: '50'
  states: {}
- name: satellites_nrzi_encode_0
  id: satellites_nrzi_encode
  parameters: {}
  states: {}
- name: sub_port
  id: parameter
  parameters:
    label: Input
    short_id: s
    value: '"5500"'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: modulator_out
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: encoder_out
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: modulator_out
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: encoder_out
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: default_ip+":"+sub_port
    timeout: '100'
    type: byte
  states: {}

connections:
- [blocks_message_strobe_0, strobe, satellites_hdlc_framer_0, in]
- [blocks_pdu_to_tagged_stream_0, '0', satellites_nrzi_encode_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, satellites_hdlc_framer_0, in]
- [blocks_unpacked_to_packed_xx_0, '0', digital_gfsk_mod_0, '0']
- [digital_gfsk_mod_0, '0', virtual_sink_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', iio_fmcomms2_sink_0, '0']
- [satellites_hdlc_framer_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [satellites_nrzi_encode_0, '0', virtual_sink_0_0, '0']
- [virtual_source_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [virtual_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [virtual_source_0_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [zeromq_sub_source_0, '0', blocks_stream_to_tagged_stream_0, '0']

metadata:
  file_format: 1
